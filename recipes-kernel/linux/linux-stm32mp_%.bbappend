FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-mcan.patch"
